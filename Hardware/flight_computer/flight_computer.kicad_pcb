# Repository wFairmanOlin/ProjectOsprey

File README.md:

# Project Osprey
#### Daniel Connolly and William Fairman

A Fall 2020 Project

<p align="center">
</img>
</p>
<p align="center">
<small>
<!--This logo is a modified version of work done by <a href="https://hweishin.carbonmade.com/">Hwei-Shin Harriman</a>, a fellow Olin student.--!>
  </small>
</p>

### Overview

We are developing a flight computer and drone as an exploration in electrical, mechanical, and firmware design.

### Subsystems

#### Electrical

Our flight computer is centered around the STM32F427VIT6 microcontroller. We have selected an IMU, barometer, GPS, and magnetometer to capture all of the necessary sensor data during flight. In addition, our board is equipped with a raspberry pi zero to which we intend to connect a small camera; the raspi communicates with the STM32 via I2C. We are also including a variety of connectors based off the [pixhawk design standard](https://github.com/pixhawk/Pixhawk-Standards/blob/master/DS-009%20Pixhawk%20Connector%20Standard.pdf) in order to connect to a variety of radios (FrSky, Spektrum, telemetry modules, etc). In order to be compatible with PX4 software, our computer also contains a microSD slot and on-board flash storage. Finally, we have created a power management system based around a TI buck converter that steps down battery voltage (12-25V) to 5V. Additional low-dropout regulators have been added to provided noise-free 3V3 to the sensors, STM, and radio modules. 

Besides providing basic computer vision, we are intending on utilizing the wifi chip on the raspi to stream video over a local network.

##### PCB Design
We have designed the first revision of our flight computer using Kicad and are currently waiting for fabrication and assembly from PCBWay. The board is 4 layers (Signal, GND, VCC, Signal) and contains roughly 120 surface mounted components. The minimnum trace/spacing width is 10/10mil.

We have already been thinking about a revision 2! Heres what might be in the pipeline:
1. Onboard 2.4ghz radio (with a pcb antennae)
2. Replacing raspi with STM32H-series chip (embedded neural nets)
3. Faster primary micro-controller
4. Shrinking layout by replacing 0805 footprints with 0603 or smaller.

#### Mechanical

We are creating a 3-D printable chassis for our drone in AutoDesk's Fusion 360. At the moment, we are experimenting with Fusion 360's generative design features and how well these designs perform when 3-D printed as well as creating the basic chassis layout.

#### Firmware / Software

While we have not yet begun firmware / software development, we intend to start once we have shipped version 1 of our PCB. We expect to work in C++/C while developing for the STM32 as well as Python as we develop software on the raspberry pi.

### Goals

Our overarching goal for this project is to develop a drone capable of autonomous or semi-autonomous flight. In pursuit of this goal, we hope to advance our skills in the following areas:

1. Electrical design & PCB layout: This entails selecting the mcu, sensors, power management systems, and all supporting hardware as well as continuing to develop our KiCad knowledge.

2. Firmware development: We intend to learn C++ and advance our knowledge of firmware.

3. Computer vision: We have equipped our system with a raspberry pi with the intention of connecting a camera for basic computer vision processing.

4. Mechanical design: Taking high-level constraints about lift and drone layout into consideration, we intend to extend our CAD abilities.

Like the logo? This logo is a modified version of work done by [Hwei-Shin Harriman](https://hweishin.carbonmade.com/), a fellow Olin student.

## KiCad design Hardware/flight_computer/flight_computer.kicad_pcb

File Hardware/README.md:

# Project Osprey Electrical Hardware

We are designing a PCB in KiCad centered around an STM32 microcontroller for our flight computer.

Parts:
C1, C6, C10, C11, C12, C13, C14, C15: C_0u1; C_0805
C2, C4: C_8p; C_0805
C3, C5, C8, C9: C_2u2; C_0805
C7: C_220u; UWT0G221MCL6GS; MPN UWT0G221MCL6GS
C43: C_10u; C_0805
D1, D2: D_Schottky_10V_3A; D_SOD-323F; MPN PMEG1030EJ,115
D8: LED_0805_Green; LED_0805; MPN LG R971-KN-1
D9: LED_0805_Red; LED_0805; MPN LG R976-NR-1
J1: Micro_USB; USB_Micro-B_Molex_47346-0001
J2: MicroSD_molex; 2908-05WB-MG; MPN 2908-05WB-MG
J3: rpi_zero_w
Q2: PMOS_20V_.76A; NTA4151PT1G; MPN NTA4151PT1G
R1, R2: R_22; R_0805; MPN CR0805-FX-22R0ELF
R3: R_1K; R_0805
R4, R37, R38, R39: R_10K; R_0805
R5, R6, R7, R8, R9: R_100K; R_0805
R10, R27: R_51.1; R_0805; MPN RMCF0805FT51R1
SW1: Switch_SMT; PTS645SM43SMTR92LFS; MPN PTS645SM43SMTR92 LFS
U1: FRAM_128K; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32F427VITx; QFP50P1600X1600X160-100N
U3: MCP131T-300E_TT; SOT-23
Y1: Crystal_24MHZ; NX3225SA-24.000M-STD-CSR-1; MPN NX3225SA-24.000M-STD-CSR-1

Connections:
/ACCEL_DRDY: U2.8 (PC14); also elsewhere on the board
/BARO_CS: U2.17 (PC2); also elsewhere on the board
/DEBUG_LED_1: D8.2 (A), U2.55 (PD8)
/DEBUG_LED_2: D9.2 (A), U2.56 (PD9)
/ESC_Current_Sense: U2.46 (PE15); also elsewhere on the board
/ESC_TLM: U2.41 (PE10); also elsewhere on the board
/FMU_CH1: U2.45 (PE14); also elsewhere on the board
/FMU_CH2: U2.44 (PE13); also elsewhere on the board
/FMU_CH3: U2.42 (PE11); also elsewhere on the board
/FMU_CH4: U2.40 (PE9); also elsewhere on the board
/FMU_UART7_RX: U2.38 (PE7); also elsewhere on the board
/FMU_UART7_TX: U2.39 (PE8); also elsewhere on the board
/FMU_USART2_CTS: U2.84 (PD3); also elsewhere on the board
/FMU_USART2_RTS: U2.85 (PD4); also elsewhere on the board
/FMU_USART2_RX: U2.87 (PD6); also elsewhere on the board
/FMU_USART2_TX: U2.86 (PD5); also elsewhere on the board
/FMU_USART8_RX: U2.97 (PE0); also elsewhere on the board
/FMU_USART8_TX: U2.98 (PE1); also elsewhere on the board
/FRAM_CS: U1.1 (~CS), U2.57 (PD10)
/FRAM_MISO: U1.2 (SO), U2.53 (PB14)
/FRAM_MOSI: U1.5 (SI), U2.54 (PB15)
/FRAM_SCK: U1.6 (SCK), U2.47 (PB10)
/FrSky_INV: U2.69 (PA10); also elsewhere on the board
/GPS_USART6_RX: U2.64 (PC7); also elsewhere on the board
/GPS_USART6_TX: U2.63 (PC6); also elsewhere on the board
/GYRO_DRDY: U2.18 (PC3); also elsewhere on the board
/IMU_ACCEL_CS: U2.29 (PA4); also elsewhere on the board
/IMU_GYRO_CS: U2.26 (PA3); also elsewhere on the board
/MAG_CS: U2.3 (PE4); also elsewhere on the board
/MAG_DRDY: U2.43 (PE12); also elsewhere on the board
/OTG_FS_D_N: R1.1, U2.70 (PA11)
/OTG_FS_D_P: R2.1, U2.71 (PA12)
/RASPI_I2C1_SCL: J3.5 (SCL/GPIO3), R38.2, U2.95 (PB8)
/RASPI_I2C1_SDA: J3.3 (SDA/GPIO2), R39.2, U2.96 (PB9)
/RC_INPUT_USART1_RX: U2.93 (PB7); also elsewhere on the board
/RC_OUTPUT_USART1_TX: U2.92 (PB6); also elsewhere on the board
/RPI_POWER_CTRL: Q2.1 (G), U2.5 (PE6)
/RSSI_IN: U2.37 (PB2); also elsewhere on the board
/SBUS_INV: U2.36 (PB1); also elsewhere on the board
/SDIO_CK: J2.5, U2.80 (PC12)
/SDIO_CMD: J2.3, R5.2, U2.83 (PD2)
/SDIO_D0: J2.7, R9.2, U2.65 (PC8)
/SDIO_D1: J2.8, R8.2, U2.66 (PC9)
/SDIO_D2: J2.1, R7.2, U2.78 (PC10)
/SDIO_D3: J2.2, R6.2, U2.79 (PC11)
/SENSOR_MISO: U2.31 (PA6); also elsewhere on the board
/SENSOR_MOSI: U2.32 (PA7); also elsewhere on the board
/SENSOR_SCK: U2.30 (PA5); also elsewhere on the board
/SERVO_CH2_GPIO: U2.82 (PD1); also elsewhere on the board
/SWCLK: U2.76 (PA14); also elsewhere on the board
/SWDIO: U2.72 (PA13); also elsewhere on the board
/SWITCH: C43.1, R37.1, U2.88 (PD7)
/VBAT_SENSE: U2.25 (PA2); also elsewhere on the board
/VDD_3V3_RADIO_EN: U2.34 (PC5); also elsewhere on the board
/VDD_3V3_SENSORS_EN: U2.2 (PE3); also elsewhere on the board
/VDD_3V3_STM: C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, J2.4, R3.2, R5.1, R6.1, R7.1, R8.1, R9.1, R38.1, R39.1, U1.3 (~WP), U1.7 (~HOLD), U1.8 (Vdd), U2.11 (VDD), U2.19 (VDD), U2.21 (VREF+), U2.22 (VDDA), U2.28 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD), U3.3 (VDD); also elsewhere on the board
/VDD_5V_IN: Q2.2 (S); also elsewhere on the board
/VDD_5V_SENSE: U2.24 (PA1); also elsewhere on the board
/VDD_5V_USB: C1.1, J1.1 (VBUS); also elsewhere on the board
/VDD_BUCK_VALID: U2.91 (PB5); also elsewhere on the board
/VDD_USB_VALID: U2.51 (PB12); also elsewhere on the board
/~RST: U2.14 (NRST), U3.2 (~RST)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C43.2, J1.5 (GND), J2.6, J3.6 (GND), J3.9 (GND), J3.14 (GND), J3.20 (GND), J3.25 (GND), J3.30 (GND), J3.34 (GND), J3.39 (GND), R4.2, R10.2, R27.2, SW1.3 (B), SW1.4 (B), U1.4 (Vss), U2.10 (VSS), U2.20 (VSSA), U2.27 (VSS), U2.74 (VSS), U2.99 (VSS), U3.1 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: C2.1, U2.12 (PH0), Y1.3
unnamed: C3.1, U2.49 (VCAP_1)
unnamed: C4.2, U2.13 (PH1), Y1.1
unnamed: C5.1, U2.73 (VCAP_2)
unnamed: C7.1, D1.1 (K), U2.6 (VBAT)
unnamed: D1.2 (A), R3.1
unnamed: D2.1 (K), J3.2 (5V), J3.4 (5V)
unnamed: D2.2 (A), Q2.3 (D)
unnamed: D8.1 (K), R10.1
unnamed: D9.1 (K), R27.1
unnamed: J1.2 (D-), R1.2
unnamed: J1.3 (D+), R2.2
unnamed: R4.1, U2.94 (BOOT0)
unnamed: R37.2, SW1.1 (A), SW1.2 (A)

Notes on the sheet:
RPI <500mA
STM32 <270mA
STM RESET WATCHDOG
SPI FRAM
BATTERY = VBAT BUCK CONVERTER OUTPUT (VDD_5V_BRICK) = VDD_5V_BUCK USB POWER (VBUS) = VDD_5V_USB RADIO 5V (VDD_5V_RECEIVER) = VDD_5V_RADIO GENERAL 5V (VDD_5V_IN) = VDD_5V_IN TELEM/FRSKY (VDD_5V_PERIPH) = VDD_5V_AUX STM POWER (FMU_VDD_3V3) = VDD_3V3_STM SENSORS POWER (VDD_3V3_SENSORS) = VDD_3V3_SENSO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
VBAT comes in from ESC

Parts:
C16, C17: C_2u2; C_0805
J4: JST_8_RA; JST_SM08B-SRSS-TB(LF)(SN)
J5: JST_GH_6_RA; JST_SM06B-GHS-TB(LF)(SN); MPN SM06B-GHS-TB(LF)(SN)
J6: JST_GH_4_RA; JST_SM04B-GHS-TB(LF)(SN)-; MPN SM04B-GHS-TB(LF)(SN)-
J7: JST_GH_5_RA; SM05B-GHS-TBLFSN; MPN SM05B-GHS-TB(LF)(SN)
J8, J9: Conn_02x03; TSW-103-07-F-D
R11: R_10K; R_0805
R12: R_470; R_0805
R13, R14: R_1K; R_0805
U4, U5: Dual_XOR_GATE; TSSOP-8_3x3mm_Pitch0.65mm; MPN 74LVC2G86DP,125

Connections:
/CONNECTORS/rc_in: J7.2, R12.1, U4.2 (1B)
/CONNECTORS/rx_frsky: J6.3, R14.2
/CONNECTORS/tx_frsky: J6.2, R13.2
/ESC_Current_Sense: J4.5; also elsewhere on the board
/ESC_TLM: J4.7; also elsewhere on the board
/FMU_CH1: J4.4; also elsewhere on the board
/FMU_CH2: J4.3; also elsewhere on the board
/FMU_CH3: J4.2; also elsewhere on the board
/FMU_CH4: J4.1; also elsewhere on the board
/FMU_UART7_RX: J8.3; also elsewhere on the board
/FMU_UART7_TX: J8.2; also elsewhere on the board
/FMU_USART2_CTS: J5.4; also elsewhere on the board
/FMU_USART2_RTS: J5.5; also elsewhere on the board
/FMU_USART2_RX: J5.3; also elsewhere on the board
/FMU_USART2_TX: J5.2; also elsewhere on the board
/FMU_USART8_RX: U5.3 (2Y); also elsewhere on the board
/FMU_USART8_TX: U5.2 (1B); also elsewhere on the board
/FrSky_INV: U5.1 (1A), U5.5 (2A); also elsewhere on the board
/RC_INPUT_USART1_RX: U4.7 (1Y); also elsewhere on the board
/RC_OUTPUT_USART1_TX: U4.6 (2B); also elsewhere on the board
/RSSI_IN: R11.2; also elsewhere on the board
/SBUS_INV: U4.1 (1A), U4.5 (2A); also elsewhere on the board
/SERVO_CH2_GPIO: J9.6; also elsewhere on the board
/SWCLK: J8.5; also elsewhere on the board
/SWDIO: J8.4; also elsewhere on the board
/VBAT: J4.8; also elsewhere on the board
/VDD_3V3_RADIO: J7.4; also elsewhere on the board
/VDD_3V3_STM: J8.1, U4.8 (VCC), U5.8 (VCC); also elsewhere on the board
/VDD_5V_RADIO: C16.1, C17.1, J5.1, J6.1, J7.1; also elsewhere on the board
GND: C16.2, C17.2, J4.6, J5.6, J6.4, J7.5, J8.6, J9.3, J9.4, U4.4 (GND), U5.4 (GND); also elsewhere on the board
unnamed: J7.3, R11.1
unnamed: R12.2, U4.3 (2Y)
unnamed: R13.1, U5.7 (1Y)
unnamed: R14.1, U5.6 (2B)

Notes on the sheet:
ESC Connection
Debug Port
TELEM1 100mA
FrSky Telemetry/Serial 4
RC Input
100mA
BATTERY = VBAT BUCK CONVERTER OUTPUT (VDD_5V_BRICK) = VDD_5V_BUCK USB POWER (VBUS) = VDD_5V_USB RADIO 5V (VDD_5V_RECEIVER) = VDD_5V_RADIO GENERAL 5V (VDD_5V_IN) = VDD_5V_IN TELEM/FRSKY (VDD_5V_PERIPH) = VDD_5V_AUX STM POWER (FMU_VDD_3V3) = VDD_3V3_STM SENSORS POWER (VDD_3V3_SENSORS) = VDD_3V3_SENSO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

Parts:
C18, C27, C30, C33, C34: C_10u; C_0805
C19, C26: C_100u; 10SGV100M6.3X6.1; MPN 10SGV100M6.3X6.1
C20, C22, C31, C32: C_0u1; C_0805
C21: C_0u012; C_0805; MPN GRM2195C1H123GA01D
C23: C_120P; C_0805; MPN CL21C121JDCNNNC
C24, C25: C_47u; C_0805; MPN JMK212BJ476MG-T
C28, C29: C_2u2; C_0805
D3: D_Schottky_x2_20V; SOT1061; MPN PMEG2020CPA,115
D4: TVS_DIODE_14V; C_0402
D5: LED_GREEN; LED_0603_HandSoldering
D6: D_Schottky_10V_3A; D_SOD-323F; MPN PMEG1030EJ,115
F1: PTC_6V_2A; Fuse_SMD1206_HandSoldering; MPN 0ZCJ0200FF2C
F2, F3: PTC_6V_1A; R_0805_HandSoldering; MPN 0ZCK0050FF2E
FL1: EMI_Filter_CLC_100MHZ; NFL21SP107X1C3D; MPN NFL21SP107X1C3D
L2: L_15u; 744066150; MPN 744066150
R15, R24, R25, R27, R31, R32: R_220; R_0805
R16: R_43K2; R_0805
R17: R_69K8; R_0805; MPN RC0805FR-0769K8L
R18, R19, R21, R22, R30: R_10K; R_0805
R20: R_470; R_0805
R23: R_143K; R_0805
R26: R_3K74; R_0805; MPN RMCF0805FT3K74
R28: R_100K; R_0805
R29: R_19K1; R_0805; MPN CRCW080519K1FKEA
U6: Buck_Converter_2; TPS54335ADDA; MPN TPS54335ADDA
U7: LDO_600MA; SOT-25_DIO; MPN AP7365-33WG-7
U8, U9: LP5907QMFX-3.3; SOT-23-5; MPN LP5907QMFX-3.3Q1

Connections:
/Power/VDD_5V_BUCK: C24.1, C25.1, F1.1, L2.2, R28.1
/Power/vsense: R28.2, R29.1, U6.5 (VSENSE)
/VBAT: C18.2, C20.1, R15.2, R17.1, U6.2 (VIN); also elsewhere on the board
/VBAT_SENSE: R17.2, R18.1; also elsewhere on the board
/VDD_3V3_RADIO: C30.1, C32.1, U7.5 (VO); also elsewhere on the board
/VDD_3V3_RADIO_EN: R30.1, U7.3 (EN); also elsewhere on the board
/VDD_3V3_SENSORS: C31.1, C33.1, R32.1, U8.5 (OUT); also elsewhere on the board
/VDD_3V3_SENSORS_EN: U8.3 (EN); also elsewhere on the board
/VDD_3V3_STM: C34.1, R31.1, U9.5 (OUT); also elsewhere on the board
/VDD_5V_IN: C26.1, C27.1, C29.1, D3.3 (K), D4.2 (A2), D5.2, D6.2 (A), F3.1, FL1.1, R21.1, U7.1 (VI), U9.1 (IN), U9.3 (EN); also elsewhere on the board
/VDD_5V_RADIO: F2.2; also elsewhere on the board
/VDD_5V_SENSE: R21.2, R22.1; also elsewhere on the board
/VDD_5V_USB: D3.2 (A), R19.1, R20.1; also elsewhere on the board
/VDD_BUCK_VALID: R24.2, R25.1; also elsewhere on the board
/VDD_USB_VALID: R19.2; also elsewhere on the board
GND: C18.1, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, D4.1 (A1), FL1.2, R16.1, R18.2, R20.2, R22.2, R23.2, R25.2, R27.2, R29.2, R30.2, R31.2, R32.2, U6.4 (GND), U6.9 (PAD), U7.2 (GND), U8.2 (GND), U9.2 (GND); also elsewhere on the board
unnamed: C19.1, D3.1 (A), F1.2, R24.1
unnamed: C21.1, R26.2
unnamed: C22.1, L2.1, U6.3 (PH)
unnamed: C22.2, U6.1 (BOOT)
unnamed: C23.1, R26.1, U6.6 (COMP)
unnamed: C28.1, FL1.3, U8.1 (IN)
unnamed 90: D5.1; also elsewhere on the board
unnamed: D6.1 (K), F2.1
unnamed 94: R27.1; also elsewhere on the board
unnamed: R15.1, R16.2, U6.7 (EN)
unnamed: R23.1, U6.8 (RT)

Notes on the sheet:
BUCK CONVERTER 8-25V, 3A
STM LDO 3V3
SENSORS LDO 3V3
5V PROTECTION CIRCUIT
PERIPHERAL POWER LDO 3V3
BATTERY = VBAT BUCK CONVERTER OUTPUT (VDD_5V_BRICK) = VDD_5V_BUCK USB POWER (VBUS) = VDD_5V_USB RADIO 5V (VDD_5V_RECEIVER) = VDD_5V_RADIO GENERAL 5V (VDD_5V_IN) = VDD_5V_IN TELEM/FRSKY (VDD_5V_PERIPH) = VDD_5V_AUX STM POWER (FMU_VDD_3V3) = VDD_3V3_STM SENSORS POWER (VDD_3V3_SENSORS) = VDD_3V3_SENSO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

Parts:
C35, C36, C39, C40, C41: C_0u1; C_0805
C37: C_4u7; C_0805
C38: C_1u; C_0805
C42: C_220u; UWT0G221MCL6GS; MPN UWT0G221MCL6GS
D7: D_Schottky_10V_3A; D_SOD-323F; MPN PMEG1030EJ,115
FL2: EMI_Filter_CLC_100MHZ; NFL21SP107X1C3D; MPN NFL21SP107X1C3D
R33, R36: R_220; R_0805
R34: R_1K; R_0805
U10: CAM-M8Q-0; CAM_M8Q_0
U11: BMI088
U12: LIS3MDLTR
U13: Barometer; MS561101BA03-50; MPN MS561101BA03-50

Connections:
/ACCEL_DRDY: U11.16 (INT1); also elsewhere on the board
/BARO_CS: U13.5 (CSB); also elsewhere on the board
/GPS_USART6_RX: R33.1; also elsewhere on the board
/GPS_USART6_TX: R36.2; also elsewhere on the board
/GYRO_DRDY: U11.12 (INT3); also elsewhere on the board
/IMU_ACCEL_CS: U11.14 (CSB1); also elsewhere on the board
/IMU_GYRO_CS: U11.5 (CSB2); also elsewhere on the board
/MAG_CS: U12.10 (CS); also elsewhere on the board
/MAG_DRDY: U12.8 (DRDY); also elsewhere on the board
/SENSOR_MISO: U11.10 (SD02), U11.15 (SD01), U12.9 (SDO/SA1), U13.6 (SDO); also elsewhere on the board
/SENSOR_MOSI: U11.9 (SDx), U12.11 (SDA/SDI/SDO), U13.7 (SDI/A); also elsewhere on the board
/SENSOR_SCK: U11.8 (SCx), U12.1 (SCL/SPC), U13.8 (SCLK); also elsewhere on the board
/Sensors/GPS_VCC: C37.2, FL2.3, R34.2, U10.1 (VCC_IO), U10.9 (VCC)
/Sensors/RF_SIGNALS: U10.16 (RF_OUT), U10.17 (RF_IN)
/Sensors/V_BCKP: C42.1, D7.1 (K), U10.8 (V_BCKP)
/VDD_3V3_SENSORS: C35.2, C36.1, C38.1, C39.1, C41.1, FL2.1, U11.3 (VDD), U11.11 (VDDIO), U12.5 (VDD), U12.6 (VDD_IO), U13.1 (VDD); also elsewhere on the board
GND: C35.1, C36.2, C37.1, C38.2, C39.2, C40.2, C41.2, C42.2, FL2.2, U10.4 (GND), U10.5 (GND), U10.10 (GND), U10.11 (GND), U10.12 (GND), U10.13 (GND), U10.14 (GND), U10.15 (GND), U10.18 (GND), U10.19 (GND), U10.21 (GND), U10.22 (GND), U10.27 (GND), U10.31 (GND), U11.4 (GNDA), U11.6 (GNDio), U11.7 (PS), U12.2 (RES), U12.3 (GND), U13.2 (PS), U13.3 (GND); also elsewhere on the board
unnamed: C40.1, U12.4 (C1)
unnamed: D7.2 (A), R34.1
unnamed: R33.2, U10.26 (RXD/SPI_MOSI)
unnamed: R36.1, U10.25 (TXD/SPI_MISO)

Notes on the sheet:
Magnetometer 40-270uA
IMU 150uA
GPS <71mA, avg <26mA
barometer <1.4mA
Note for the EMI filter that the GPS here is at 3.3V not 5V like in the pixracer
GPS MODULE
IMU
MAGNETOMETER
BAROMETER
Check VDDIO connection

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
Board: 4 copper layers, 80.0 x 100.0 mm, 123 parts (0 on the bottom side), 109 nets.

Other parts of the board:
J10: Conn_02x01; TSW-102-07-F-S
R35: R_120; R_0805

Their connections:
/VBAT: J10.1; also elsewhere on the board
GND: J10.2, R35.2; also elsewhere on the board
unnamed 90: R35.1; also elsewhere on the board

File Hardware/bom_rev1.xlsx:

|  |  | REV 1 BOM
Item # | *Designator | *Qty | Manufacturer | *Mfg Part # | Description / Value | *Package/Footprint | Type | Your Instructions / Notes
1 | C19, C26 | 2 | Rubycon | 10SGV100M6.3X6.1 | C_100u | SMD | SMD
2 | C21 | 1 | Murata Electronics | GRM2195C1H123GA01D | C_0u012 | 0805 | SMD
3 | C23 | 1 | Samsung Electro-Mechanics | CL21C121JDCNNNC | C_120P | 0805 | SMD
4 | C24, C25 | 2 | Taiyo Yuden | JMK212BJ476MG-T | C_47u | 0805 | SMD
5 | C37 | 1 | Murata Electronics | GRM21BR71C475KE51L | C_4u7 | 0805 | SMD
6 | C38 | 1 | KEMET | C0805C105Z4VACTU | C_1u | 0805 | SMD
7 | C4, C2 | 2 | Yageo | CC0805DRNPO9BN8R0 | C_8p | 0805 | SMD
8 | C43, C18, C34, C33, C27, C30 | 6 | Murata Electronics | GRM21BR61E106KA73K | C_10u | 0805 | SMD
9 | C6, C10, C11, C12, C14, C15, C13, C1, C20, C22, C31, C32, C36, C40, C39, C41, C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 | 17 | AVX Corporation | 08055C104JAT2A | C_0u1 | 0805 | SMD
10 | C7, C42 | 2 | Nichicon | UWT0G221MCL6GS | C_220u | SMD | SMD
11 | C9, C8, C3, C5, C16, C17, C29, C28 | 8 | TDK Corporation | CGB4B1X6S1C225K055AC | C_2u2 | 0805 | SMD
12 | D2, D1, D6, D7 | 4 | Nexperia USA Inc. | PMEG1030EJ,115 | D_Schottky_10V_3A | D_SOD-323F | SMD
13 | D3 | 1 | Nexperia USA Inc. | PMEG2020CPA,115 | D_Schottky_x2_20V | SOT1061 | SMD
14 | D4 | 1 | Littelfuse Inc. | PESD0402-140 | TVS_DIODE_14V | 0402 | SMD
15 | D8, D5 | 2 | OSRAM Opto Semiconductors Inc. | LG R971-KN-1 | LED_0805_Green | 0805 | SMD
16 | D9 | 1 | OSRAM Opto Semiconductors Inc. | LG R976-NR-1 | LED_0805_Red | 0805 | SMD
17 | F1 | 1 | Bel Fuse Inc. | 0ZCJ0200FF2C | PTC_6V_2A | 1206 | SMD
18 | F2, F3 | 2 | Bel Fuse Inc. | 0ZCK0050FF2E | PTC_6V_1A | 0805 | SMD
19 | FL1, FL2 | 2 | Murata Electronics | NFL21SP107X1C3D | EMI_Filter_CLC_100MHZ | SMD | SMD
20 | J1 | 1 | Molex | 473460001 | Micro_USB | SMD | SMD
21 | J10 | 1 | N/A | N/A | N/A | N/A | DNS | ignore part
22 | J2 | 1 | 3M | 2908-05WB-MG | MicroSD_molex | SMD | SMD
23 | J3 | 1 | N/A | N/A | N/A | N/A | DNS | ignore part
24 | J4 | 1 | JST Sales America Inc. | SM08B-SRSS-TB(LF)(SN) | JST_8_RA | SMD | SMD
25 | J5 | 1 | JST Sales America Inc. | SM06B-GHS-TB(LF)(SN) | JST_GH_6_RA | SMD | SMD
26 | J6 | 1 | JST Sales America Inc. | SM04B-GHS-TB(LF)(SN)- | JST_GH_4_RA | SMD | SMD
27 | J7 | 1 | JST Sales America Inc. | SM05B-GHS-TB(LF)(SN) | JST_GH_5_RA | SMD | SMD
28 | J8, J9 | 2 | Samtec Inc. | TSW-103-07-F-D | Conn_02x03 | through hole | through hole
29 | L2 | 1 | Würth Elektronik | 744066150 | L_15u | SMD | SMD
30 | Q2 | 1 | ON Semiconductor | NTA4151PT1G | PMOS_20V_.76A | SMD | SMD
31 | R1, R2 | 2 | Bourns Inc. | CR0805-FX-22R0ELF | R_22 | 0805 | SMD
32 | R10, R27 | 2 | Stackpole Electronics Inc | RMCF0805FT51R1 | R_51.1 | 0805 | SMD
33 | R12, R20 | 2 | TE Connectivity Passive Product | CRGCQ0805F470R | R_470 | 0805 | SMD
34 | R15, R31, R32, R25, R24, R36, R33 | 7 | Yageo | RC0805FR-07220RL | R_220 | 0805 | SMD
35 | R16 | 1 | Yageo | RC0805FR-0743K2L | R_43K2 | 0805 | SMD
36 | R17 | 1 | Yageo | RC0805FR-0769K8L | R_69K8 | 0805 | SMD
37 | R23 | 1 | Stackpole Electronics Inc | RMCF0805FT143K | R_143K | 0805 | SMD
38 | R26 | 1 | Stackpole Electronics Inc | RMCF0805FT3K74 | R_3K74 | 0805 | SMD
39 | R29 | 1 | Vishay Dale | CRCW080519K1FKEA | R_19K1 | 0805 | SMD
40 | R3, R13, R14, R34 | 4 | Yageo | RC0805JR-071KL | R_1K | 0805 | SMD
41 | R35 | 1 | TE Connectivity Passive Product | CRGCQ0805F120R | R_120 | 0805 | SMD
42 | R39, R38 | 2 | Yageo | RC0805FR-0710KL | R_10K | 0805 | SMD
43 | R4, R37, R11, R30, R19, R22, R21, R18 | 8 | Yageo | RC0805FR-07100KL | R_10K | 0805 | SMD
44 | R9, R8, R7, R6, R5, R28 | 6 | Stackpole Electronics Inc | RMCF0805JT68R0 | R_100K | 0805 | SMD
45 | SW1 | 1 | C&K | PTS645SM43SMTR92 LFS | Switch_SMT | SMD | SMD
46 | U1 | 1 | Cypress Semiconductor Corp | FM25V01A-G | FRAM_128K | SOIC-8 | SMD
47 | U10 | 1 | U-Blox | CAM-M8Q-0 | CAM-M8Q-0 | SMD | SMD
48 | U11 | 1 | Bosch Sensortec | BMI088 | BMI088 | SMD | SMD
49 | U12 | 1 | STMicroelectronics | LIS3MDLTR | LIS3MDLTR | SMD | SMD
50 | U13 | 1 | TE Connectivity Measurement Specialties | MS561101BA03-50 | Barometer | SMD | SMD
51 | U2 | 1 | STMicroelectronics | STM32F427VIT6 | STM32F427VITx | SMD | SMD
52 | U3 | 1 | Microchip Technology | MCP131T-300E/TT | MCP131T-300E_TT | SOT-23 | SMD
53 | U5, U4 | 2 | Nexperia USA Inc. | 74LVC2G86DP,125 | Dual_XOR_GATE | TSSOP-8 | SMD
54 | U6 | 1 | Texas Instruments | TPS54335ADDA | Buck_Converter_2 | SMD | SMD
55 | U7 | 1 | Diodes Incorporated | AP7365-33WG-7 | LDO_600MA | SOT-25_DIO | SMD
56 | U9, U8 | 2 | Texas Instruments | LP5907QMFX-3.3Q1 | LP5907QMFX-3.3 | SOT-23-5 | SMD
57 | Y1 | 1 | NDK America, Inc. | NX3225SA-24.000M-STD-CSR-1 | Crystal_24MHZ | SMD | SMD

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
